# Repository sidhb23/Alfond-Data-Logger

## EAGLE design Alfond_PCB/Models/Adafruit-MS8607-PCB/Adafruit MS8607.brd

Parts:
C1: 0.1uF; 0603-NO
C2, C3: 10uF; 0805-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
FID3, FID4: FIDUCIAL_1MM
JP2: HEADER-1X5ROUND; 1X05_ROUND
Q2: BSS138; SOT363
R1: 10K; 0603-NO
R3: 10K; RESPACK_4X0603
U2: AP2112K-3.3; SOT23-5
U$1, U$17, U$19, U$21: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
X1: MS8607

Connections:
3.3V: C1.1, C3.1, JP2.2, Q2.2 (G), Q2.5 (G), R1.1, R3.2 (1), R3.4 (1), U2.5 (OUT), X1.1 (VDD)
GND: C1.2, C2.2, C3.2, CONN3.1 (GND), CONN3.MT1 (MT), CONN3.MT2 (MT), CONN4.1 (GND), CONN4.MT1 (MT), CONN4.MT2 (MT), D1.C, JP2.3, U2.2 (GND), X1.3 (GND)
unnamed: D1.A, R1.2
SCL: CONN3.4 (SCL), CONN4.4 (SCL), JP2.4, Q2.6 (D), R3.8 (2)
SCL_3V: Q2.1 (S), R3.7 (2), X1.8 (SCL)
SDA: CONN3.3 (SDA), CONN4.3 (SDA), JP2.5, Q2.3 (D), R3.6 (2)
SDA_3V: Q2.4 (S), R3.5 (2), X1.7 (SDA)
VCC: C2.1, CONN3.2 (V+), CONN4.2 (V+), JP2.1, R3.1, R3.3 (1), U2.1 (IN), U2.3 (EN)

Notes on the sheet:
I2C Pullups & Shift
STEMMA/I2C Headers
ON LED
Power supply

Board: 2 copper layers, 24.9 x 17.3 mm, 22 parts (3 on the bottom side), 8 nets.

Other parts of the board:
U$22: ADAFRUIT_3.5MM
U$25: PCBFEAT-REV-040
U$30, U$31: STEMMAQT

## Commit log

2024-09-27 Added the kicad files and stm32IDE files
2024-09-27 added kicad and stm32ide files and updated readme
2024-10-06 Removed stm32ide files because they were causing errors
2024-10-06 removed stm32ide files
2024-10-06 Updated kicad schematics
2024-10-06 Updated schematic with xbee, sd card slot and button
2024-10-07 added footprints to the symbols
2024-10-08 copy with the stm32u535
2024-10-08 saved copy with the stm32u535
2024-10-09 Changed MCU to STM32U545VET6
2024-10-23 Addedd STM32IDE Files
2024-10-26 Initial commit of STM32 project
2024-10-26 added Rpi Zigbee script
2024-11-21 Made the U545 project the primary project rather than zipping the project
2024-11-24 added the Raspberry Pi script to the new main branch and also added README
2024-11-24 updated README with a brief description
2024-11-24 changed project files to the most recent changes
2024-11-25 Further PCB design
    Found the issue with connecting adafruit through hole pins, and the rest of the PCB along with connecting more components
2024-11-26 updated Rpi script
2024-11-27 Removed layers
    Had extra copper layers that weren't used, and forgot to comment on the last push, but it was creating a fully connected pcb
2024-11-27 Footprints Used
    Added all the external footprints needed to properly view the PCB and schematic
2024-11-27 Updated the schematic and PCB
    The schematic and PCB had a generic MIC symbol and footprint, however the MIC that was ordered had 5 pins while the one in the PCB had 8.
2024-11-27 Delete Alfond_PCB (1) directory
    Added updated pcb changes, but it got added as a new directory and not changing the current one
2024-11-27 Update to PCB and Footprints
    The PCB was updated to the correct MIC ordered from Digikey, and the footprint was added to the footprint folders.
2024-11-28 fixed few errors
2024-11-28 PCB changes
    Added text for project name and group members, along with changing capacitor 14 from a footprint that wasn't working with one that is.
2024-11-28 Final PCB Changes
    Changed the Schottky diodes to the MAX40200 diodes
2024-11-28 Added test points
    Added test points for possible debugging of PCB
2024-12-11 Latest PCB Changes
    PCB changes for the PCB order that was made on 12/07/2024
2025-01-31 PCB order 2
2025-02-05 made improvments to pcb
2025-02-14 made changes to switch placement
2025-03-11 Final PCB Code

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
